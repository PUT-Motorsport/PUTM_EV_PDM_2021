# Repository PUT-Motorsport/PUTM_EV_PDM_2021 (continued)

## KiCad design Hardware/PDM.kicad_pcb (continued)

Schematic: IsoOUTPUT.sch

Parts:
R160, R161, R162, R163: 10R; R_0603_1608Metric
R164, R165, R166, R167: 10k; R_0603_1608Metric
U33, U34, U35, U36: SFH617A-1; DIP-4_W7.62mm

Connections:
DigitalOut1: R164.1, U33.3; also elsewhere on the board
DigitalOut2: R165.1, U34.3; also elsewhere on the board
DigitalOut3: R166.1, U35.3; also elsewhere on the board
DigitalOut4: R167.1, U36.3; also elsewhere on the board
GND: R164.2, R165.2, R166.2, R167.2, U33.2, U34.2, U35.2, U36.2; also elsewhere on the board
unnamed: R160.2, U33.4
unnamed: R161.2, U34.4
unnamed: R162.2, U35.4
unnamed: R163.2, U36.4
SensorSupply: R160.1, R161.1, R162.1, R163.1; also elsewhere on the board
uC_out1: U33.1; also elsewhere on the board
uC_out2: U34.1; also elsewhere on the board
uC_out3: U35.1; also elsewhere on the board
uC_out4: U36.1; also elsewhere on the board

Schematic: Driver.sch

Parts:
C35: C_Small; C_0603_1608Metric
Q44, Q45, Q46: Q_NMOS_GSD; SOT-23
R168, R169, R176, R177, R178: 10k; R_0603_1608Metric
R170, R171, R172: 2k; R_0603_1608Metric
R173, R174, R175: 100R; R_0603_1608Metric
U37: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+5V: C35.1, U37.9 (VDD), U37.18 (~RESET~); also elsewhere on the board
+12V: R170.1, R171.1, R172.1; also elsewhere on the board
Drive1: U37.1 (GPB0); also elsewhere on the board
Drive2: U37.2 (GPB1); also elsewhere on the board
Drive3: U37.3 (GPB2); also elsewhere on the board
Drive4: U37.4 (GPB3); also elsewhere on the board
Drive5: U37.5 (GPB4); also elsewhere on the board
Drive6: U37.6 (GPB5); also elsewhere on the board
Drive7: U37.7 (GPB6); also elsewhere on the board
Drive8: U37.8 (GPB7); also elsewhere on the board
Drive9: U37.21 (GPA0); also elsewhere on the board
Drive10: U37.22 (GPA1); also elsewhere on the board
Drive11: U37.23 (GPA2); also elsewhere on the board
Drive12: U37.24 (GPA3); also elsewhere on the board
Drive13: U37.25 (GPA4); also elsewhere on the board
Drive21_1: Q44.3 (D), R170.2; also elsewhere on the board
Drive22_1: Q45.3 (D), R171.2; also elsewhere on the board
Drive23_1: Q46.3 (D), R172.2; also elsewhere on the board
Drive25: U37.26 (GPA5); also elsewhere on the board
Drive26: U37.27 (GPA6); also elsewhere on the board
GND: C35.2, Q44.2 (S), Q45.2 (S), Q46.2 (S), R176.2, R177.2, R178.2, U37.10 (VSS), U37.15 (A0), U37.16 (A1), U37.17 (A2); also elsewhere on the board
HC_drive1: R173.2; also elsewhere on the board
HC_drive2: R174.2; also elsewhere on the board
HC_drive3: R175.2; also elsewhere on the board
unnamed: Q44.1 (G), R173.1, R176.1
unnamed: Q45.1 (G), R174.1, R177.1
unnamed: Q46.1 (G), R175.1, R178.1
SCK: R169.1, U37.12 (SCK); also elsewhere on the board
SDA: R168.1, U37.13 (SDA); also elsewhere on the board
SW_VDD: R168.2, R169.2; also elsewhere on the board

Schematic: Multiplexers.sch

Parts:
C36, C37, C38: 100n; C_0603_1608Metric
U38, U39, U40: 74HC4051; TSSOP-16_4.4x5mm_P0.65mm

Connections:
ADC0: U38.3 (A); also elsewhere on the board
ADC1: U39.3 (A); also elsewhere on the board
ADC2: U40.3 (A); also elsewhere on the board
ADC_s0: U38.11 (S0); also elsewhere on the board
ADC_s1: U38.10 (S1); also elsewhere on the board
ADC_s2: U38.9 (S2); also elsewhere on the board
ADC_s3: U39.11 (S0); also elsewhere on the board
ADC_s4: U39.10 (S1); also elsewhere on the board
ADC_s5: U39.9 (S2); also elsewhere on the board
ADC_s6: U40.11 (S0); also elsewhere on the board
ADC_s7: U40.10 (S1); also elsewhere on the board
ADC_s8: U40.9 (S2); also elsewhere on the board
Curent1: U38.13 (A0); also elsewhere on the board
Curent2: U38.14 (A1); also elsewhere on the board
Curent3: U38.15 (A2); also elsewhere on the board
Curent4: U38.12 (A3); also elsewhere on the board
Curent5: U38.1 (A4); also elsewhere on the board
Curent6: U38.5 (A5); also elsewhere on the board
Curent7: U38.2 (A6); also elsewhere on the board
Curent8: U38.4 (A7); also elsewhere on the board
Curent9: U39.13 (A0); also elsewhere on the board
Curent10: U39.14 (A1); also elsewhere on the board
Curent11: U39.15 (A2); also elsewhere on the board
Curent12: U39.12 (A3); also elsewhere on the board
Curent13: U39.1 (A4); also elsewhere on the board
Curent21: U39.5 (A5); also elsewhere on the board
Curent22: U39.2 (A6); also elsewhere on the board
Curent23: U39.4 (A7); also elsewhere on the board
Curent24: U40.13 (A0)
Curent25: U40.14 (A1); also elsewhere on the board
Curent26: U40.15 (A2); also elsewhere on the board
GND: C36.2, C37.2, C38.2, U38.6 (~E), U38.8 (GND), U39.6 (~E), U39.8 (GND), U40.6 (~E), U40.8 (GND); also elsewhere on the board
SW_VDD: C36.1, C37.1, C38.1, U38.7 (VEE), U38.16 (VCC), U39.7 (VEE), U39.16 (VCC), U40.7 (VEE), U40.16 (VCC); also elsewhere on the board
SupplyVoltage: U40.4 (A7); also elsewhere on the board
Temp1: U40.12 (A3); also elsewhere on the board
Temp2: U40.1 (A4); also elsewhere on the board
Temp3: U40.5 (A5); also elsewhere on the board
Temp4: U40.2 (A6); also elsewhere on the board

Schematic: USB.sch

Parts:
J10: USB_B_Mini; USB_Micro-B_Molex_47346-0001
R179, R180: 10R; R_0603_1608Metric

Connections:
5V_USB: J10.1 (VBUS); also elsewhere on the board
GND: J10.5 (GND), J10.6 (Shield); also elsewhere on the board
unnamed: J10.2 (D-), R180.2
unnamed: J10.3 (D+), R179.2
USB_DM: R180.1; also elsewhere on the board
USB_DP: R179.1; also elsewhere on the board

Board: 2 copper layers, 355 parts (46 on the bottom side), 264 nets, no tracks yet.
